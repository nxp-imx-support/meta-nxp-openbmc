# i.MX91 does not support OP-TEE
COMPATIBLE_MACHINE:frdm-imx91 = "(!.*)"

