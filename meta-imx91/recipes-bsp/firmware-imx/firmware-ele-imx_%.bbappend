COMPATIBLE_MACHINE:append = "|frdm-imx91"
