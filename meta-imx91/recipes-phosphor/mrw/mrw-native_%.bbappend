FILESEXTRAPATHS:prepend:frdm-imx91 := "${THISDIR}/${PN}:"
SRC_URI:append:frdm-imx91 = " file://frdm-imx91.xml.patch.xml"
