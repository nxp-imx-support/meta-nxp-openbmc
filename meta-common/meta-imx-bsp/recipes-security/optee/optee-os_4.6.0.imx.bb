require optee-os-imx.inc

SRCBRANCH = "lf-6.12.34_2.1.0"
SRC_URI = "${OPTEE_OS_SRC};branch=${SRCBRANCH};name=os"
SRCREV_os = "788dc101b05ae47bfaa1a9e66ec620d6c0d9be19"
SRCREV_FORMAT = "os"
