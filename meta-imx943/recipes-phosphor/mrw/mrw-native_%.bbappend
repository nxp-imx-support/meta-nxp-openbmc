FILESEXTRAPATHS:prepend:evb-imx943 := "${THISDIR}/${PN}:"
SRC_URI:append:evb-imx943 = " file://evb-imx943.xml.patch.xml"
