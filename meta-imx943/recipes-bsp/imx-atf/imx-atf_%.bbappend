# Copyright 2026 NXP

# Select TF-A platform for i.MX94
ATF_PLATFORM = "imx94"
