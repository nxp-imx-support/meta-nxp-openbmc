FILESEXTRAPATHS:prepend:evb-imx93 := "${THISDIR}/${PN}:"
SRC_URI:append:evb-imx93 = " file://evb-imx93.xml.patch.xml"
