# Copyright 2026 NXP

# Select TF-A platform for i.MX93
ATF_PLATFORM = "imx93"
