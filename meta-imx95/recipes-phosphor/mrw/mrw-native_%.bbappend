FILESEXTRAPATHS:prepend:frdm-imx95 := "${THISDIR}/${PN}:"
SRC_URI:append:frdm-imx95 = " file://frdm-imx95.xml.patch.xml"
