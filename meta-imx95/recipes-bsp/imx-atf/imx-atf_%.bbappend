# Copyright 2026 NXP

# Select TF-A platform for i.MX95
ATF_PLATFORM = "imx95"
